# Keil uVision project STM32F1_Demo.uvprojx, settings and files
target STM32_Demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32_Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\User;..\FWlib\inc;..\User\bsp;..\User\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c help.c
    ../User/bsp/dwt_delay/: core_delay.c core_delay.h
    ../User/common/: button.c button.h data_pack.c data_pack.h data_process.c data_process.h heap.c heap.h PID_Control.c PID_Control.h printf.c printf.h ringbuff.c ringbuff.h
  group BSP
    ../User/bsp/led/: bsp_led.c bsp_led.h
    ../User/bsp/key/: bsp_key.c bsp_key.h
    ../User/bsp/SysTick/: bsp_SysTick.c bsp_SysTick.h
    ../User/bsp/i2c/: i2c.c i2c.h
    ../User/bsp/exti/: bsp_exti.c bsp_exti.h
    ../User/bsp/crc/: bsp_crc.c bsp_crc.h
    ../User/bsp/usart/: bsp_usart.c bsp_usart.h
    ../User/bsp/bs81xx/: bsp_bs81xx.c bsp_bs81xx.h
